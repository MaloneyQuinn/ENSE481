# Keil uVision project ball_height_controller.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F103ZG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ball_height_controller
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group source
    ./: main.c usart.c
  group Doxygen
    ./: ball_height_controller.doxy
    ./: ball_height_controller.c
  group headers
    ./: usart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
